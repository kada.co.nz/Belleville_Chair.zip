Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-11T13:41:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 11 13:41:59 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{FB55DAE0-246E-4687-A60C-AE9E3EF187E2}\ifc * Database version: 5507 * Database creation date: Fri Jan 11 13:41:56 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 11 13:41:57 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 11 13:41:57 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Belleville chair plastic, CONV_Vitra_DmstcChrs_Belleville:Belleville chair plastic:311096
In: Level 1
Material: 12 deep black, Glide black
Pset_ManufacturerTypeInformation - ModelReference: 44029800; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.0535 m2; Volume: 0.199283 m3
Materials and Finishes - ChairMainMaterial: 12 deep black
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_Belleville: Belleville chair plastic; Family and Type: CONV_Vitra_DmstcChrs_Belleville: Belleville chair plastic; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_Belleville: Belleville chair plastic; Type Id: CONV_Vitra_DmstcChrs_Belleville: Belleville chair plastic; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Belleville; ConvergoRefNr: 0089-1812-0128-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The plastic Belleville Chair consists of two components – a structural frame and a seat shell. The elegant structural frame forms the calligraphic lines of the chair's legs and backrest.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 07/01/2019
Identity Data(Type) - Collection: Belleville; Cost: 0; Description: The plastic Belleville Chair consists of two components – a structural frame and a seat shell. The elegant structural frame forms the calligraphic lines of the chair's legs and backrest – and is available with or without forward sloping armrests. The thin seat shell tapers upward from the seat into the back. In addition to the version made of coloured plastic, the shell also comes in plywood veneer or upholstered in leather or fabric. Belleville Chair Plastic is also suitable for outdoor use.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Belleville chair plastic; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/1009783/storage/master/download/FS_Bellville_Chair-EN_Preview-Single-Page.pdf; Type Name: Belleville chair plastic; URL: https://www.vitra.com/en-un/living/product/details/belleville-chair-plastic
Materials and Finishes(Type) - ChairSecondaryMaterial: 12 deep black; ChairTertiaryMaterial: Glide black
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_Belleville; Features: Stackable, maximum 6.; Finish: Seat shell, base and frame: injection-moulded polyamide. Stackable up to 6 high.; Grade: n/a; Material: Polyamide; ModelNumber: n/a; ModelReference: 44029800; Name: DmstcChrs_Belleville; ReplacementCost: n/a; Shape: Sculptured; Size: 490x490x830 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
